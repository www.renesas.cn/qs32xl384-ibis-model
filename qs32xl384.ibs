| I/O Buffer Information Specification (IBIS) Version 3.2 (August 20, 1999)
| IBIS is a standard for electronic behavioral specifications of integrated
| circuit input/output analog characteristics.
[IBIS Ver]   3.2
[File Name]   qs32xl384.ibs
[File Rev]   1.0
[Date]   February 23, 2000
[Notes]   IDT provides IBIS models as a service to our customers. You
   and your company shall not distribute, convey, sell or give
   these models to anyone else without receiving prior written
   permission from IDT. IDT reserves the right to make changes to
   its products or to discontinue any semiconductor product or
   service without notice, and advises its customers to obtain
   the latest version of relevant information to verify, before
   placing orders, that the information being relied on is
   current. Please be aware that your receipt and subsequent use
   of the IBIS information provided shall serve as acceptance of
   the terms and conditions of this agreement. If you do not
   accept these terms, you should return the IBIS model and any
   other accompanying information immediately.
[Disclaimer]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
[Copyright]   (C) Copyright 2000 Integrated Device Technology, Inc. All
   rights reserved. Unauthorized reproduction and/or distribution
   is strictly prohibited.
|   Component QS32XL384
[Component]   QS32XL384
|Project: QSW5B
[Manufacturer]   Integrated Device Technology, Inc.
[Package]
| Package parasitics.  Uncomment one set.
| variable   typ   min   max
| QSOP
R_pkg   0.01   0.01   0.01
L_pkg   2.50nH   2.50nH   2.50nH
C_pkg   0.40pF   0.40pF   0.40pF
[Pin]   signal_name   model_name   R_pin   L_pin   C_pin
|1   BEAB   ENABLE   NA   NA   NA
2   B0   NC   NA   NA   NA
3   A0   NC   NA   NA   NA
4   A1   NC   NA   NA   NA
5   B1   NC   NA   NA   NA
6   B2   NC   NA   NA   NA
7   A2   NC   NA   NA   NA
8   A3   NC   NA   NA   NA
9   B3   NC   NA   NA   NA
10   B4   NC   NA   NA   NA
11   A4   NC   NA   NA   NA
12   GND   GND   NA   NA   NA
|13   BECB   ENABLE   NA   NA   NA
14   B5   NC   NA   NA   NA
15   A5   NC   NA   NA   NA
16   A6   NC   NA   NA   NA
17   B6   NC   NA   NA   NA
18   B7   NC   NA   NA   NA
19   A7   NC   NA   NA   NA
20   A8   NC   NA   NA   NA
21   B8   NC   NA   NA   NA
22   B9   NC   NA   NA   NA
23   A9   NC   NA   NA   NA
24   GND   GND   NA   NA   NA
|25   BEDB   ENABLE   NA   NA   NA
26   A10   NC   NA   NA   NA
27   B10   NC   NA   NA   NA
28   B11   NC   NA   NA   NA
29   A11   NC   NA   NA   NA
30   A12   NC   NA   NA   NA
31   B12   NC   NA   NA   NA
32   B13   NC   NA   NA   NA
33   A13   NC   NA   NA   NA
34   A14   NC   NA   NA   NA
35   B14   NC   NA   NA   NA
36   VCC   POWER   NA   NA   NA
|37   BEBB   ENABLE   NA   NA   NA
38   A15   NC   NA   NA   NA
39   B15   NC   NA   NA   NA
40   B16   NC   NA   NA   NA
41   A16   NC   NA   NA   NA
42   A17   NC   NA   NA   NA
43   B17   NC   NA   NA   NA
44   B18   NC   NA   NA   NA
45   A18   NC   NA   NA   NA
46   A19   NC   NA   NA   NA
47   B19   NC   NA   NA   NA
48   VCC   POWER   NA   NA   NA
[Series Pin Mapping]   pin_2   model_name   function_table_group
3   2   QSIO   1
4   5   QSIO   2
7   6   QSIO   3
8   9   QSIO   4
11   10   QSIO   5
15   14   QSIO   6
16   17   QSIO   7
19   18   QSIO   8
20   21   QSIO   9
23   22   QSIO   10
26   27   QSIO   11
29   28   QSIO   12
30   31   QSIO   13
33   32   QSIO   14
34   35   QSIO   15
38   39   QSIO   16
41   40   QSIO   17
42   43   QSIO   18
45   44   QSIO   19
46   47   QSIO   20
|   Series_MOSFET   This model type is for series switch
|   devices that can described by [On], [Off],
|   [R Series], [L Series], [Rl Series],
|   [C Series], [Lc Series], [Rc Series],
|   [Series Current] and [Series MOSFET]
|   keywords
[Model]   QSIO
Model_type   Series_switch
| variable   typ   min   max
| Silicon die-compacitance (excluding package cap)
C_comp   5.26pF   NA   NA
[Temperature Range]   25.0   85   -40
[Voltage Range]   5.0V   4.75V   5.25V
[On]
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[Off]
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| Models and submodels in the file (1): QSIO (Series_switch)
